# Keil uVision project 发光管闪烁.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 发光管闪烁 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    F:/51单片机配套教辅/新建文件夹/书后例程/第二篇例程/part2_2/: part2.2_1.c
