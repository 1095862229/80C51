# Keil uVision project I2C总线.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: I2C总线 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    F:/51单片机配套教辅/新建文件夹/视频教程/lesson9/例程/: lesson9.c
